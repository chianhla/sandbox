# IAR project mouse.ewp, settings and files
configuration STM32W108xB_TX (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; MOUSE_TX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\simplemac\include; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\..\simplemac; ..\..\..\..\shared
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_tx.s37
  ILINK.IlinkOutputFile: mouse_tx.out
  ILINK.IlinkIcfFile: ../../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32W108xB_RX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: mouse_rx.s37
  ILINK.IlinkOutputFile: mouse_rx.out
configuration STM32W108CC_TX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; MOUSE_TX
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG
  ILINK.IlinkConfigDefines: STM32W108CC=1
configuration STM32W108CC_RX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: mouse_rx.s37
  ILINK.IlinkOutputFile: mouse_rx.out
  ILINK.IlinkConfigDefines: STM32W108CC=1
configuration STM32W108xB_TX-btl (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: mouse_tx-btl.s37
  ILINK.IlinkOutputFile: mouse_tx-btl.out
  ILINK.IlinkConfigDefines: ST_BTL=1
configuration STM32W108xB_RX-btl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: mouse_rx-btl.s37
  ILINK.IlinkOutputFile: mouse_rx-btl.out
  ILINK.IlinkConfigDefines: ST_BTL=1
  group hal
    ../../../../hal/micro/cortexm3/: adc.c board.c button.c clocks.c context-switch.s79 cstartup_M.s flash.c led.c mems.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
  group mouse_application
    ../: mouse.c
  group simplemac_library
    ../../../library/: simplemac-library.a
