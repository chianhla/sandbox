# IAR project sample.ewp, settings and files
configuration STM32W108xB_SUN (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\simplemac\include; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\..\simplemac; ..\..\..\..\shared
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sample_sun.s37
  ILINK.IlinkOutputFile: sample_sun.out
  ILINK.IlinkIcfFile: ../../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32W108xB_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
configuration STM32W108CC_SUN (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  AARM.ADefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ILINK.IlinkConfigDefines: STM32W108CC=1
configuration STM32W108CC_PLANET (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; PLANET_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
  ILINK.IlinkConfigDefines: STM32W108CC=1
configuration STM32W108xB_SUN-btl (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: sample_sun-btl.s37
  ILINK.IlinkOutputFile: sample_sun-btl.out
  ILINK.IlinkConfigDefines: ST_BTL=1
configuration STM32W108xB_PLANET-btl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: sample_planet-btl.s37
  ILINK.IlinkOutputFile: sample_planet-btl.out
  ILINK.IlinkConfigDefines: ST_BTL=1
  group hal
    ../../../../hal/micro/cortexm3/: adc.c board.c button.c clocks.c context-switch.s79 cstartup_M.s flash.c led.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
  group sample_application
    ../: solar-system.c transmit.c
  group simplemac_library
    ../../../library/: simplemac-library.a
