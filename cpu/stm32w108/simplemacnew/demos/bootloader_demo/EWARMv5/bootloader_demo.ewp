# IAR project bootloader_demo.ewp, settings and files
configuration STM32W108xB (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108xB; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\simplemac\include; ..\..\..\..; ..\..\..\..\hal; ..\..\..\..\hal\micro\cortexm3\stm32w108; ..\..\..\..\simplemac; ..\..\..\..\shared
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bootloader_demo.s37
  ILINK.IlinkOutputFile: bootloader_demo.out
  ILINK.IlinkIcfFile: ../../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32W108CC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108CC ST STM32W108CC
  ICCARM.CCDefines: PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; CORTEXM3_STM32W108CC; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  AARM.ADefines: as above
  ILINK.IlinkConfigDefines: STM32W108CC=1
  group (top)
    ../../../library/: simplemac-library.a
  group bootloader_application
    ../: bootloader_demo.c
  group hal
    ../../../../hal/micro/cortexm3/: adc.c board.c button.c clocks.c context-switch.s79 cstartup_M.s flash.c led.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
  group shared
    ../../../../shared/: bl.c command-interpreter2.c response.c serial_utils.c timer.c
